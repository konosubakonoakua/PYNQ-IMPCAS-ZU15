# Copyright (C) 2021 Xilinx, Inc
# SPDX-License-Identifier: BSD-3-Clause

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

python __anonymous() {
    bb.note("==================== u-boot-xlnx_%.bbappend loaded ====================")
}

